Commit message: good progress

File: asclepius/description/asclepius.xacro (robot description, xacro)
@@ -395,4 +395,5 @@
       xyz="0 0 -1" />
   </joint>
+  <!-- <link name="tool0"/> -->
   </xacro:macro>
 </robot>
